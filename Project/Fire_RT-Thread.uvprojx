# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Fire_RT-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\rthread\3.0.3\bsp;..\rthread\3.0.3\components\finsh;..\rthread\3.0.3\include;..\rthread\3.0.3\include\libc;..\rthread\3.0.3\libcpu\arm\cortex-m3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group rtt/ports
    ../rthread/3.0.3/libcpu/arm/cortex-m3/: cupport.c context_rvds.S core_cm3.c
  group rtt/source
    ../rthread/3.0.3/src/: thread.c scheduler.c object.c clock.c idle.c irq.c kservice.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
